<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bruteforce</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_freq</value></param>
<param><key>value</key><value>676</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>value</key><value>432.867e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet</value></param>
<param><key>value</key><value>"010000010[01]0[01]0101000[01]0[01]0[01]0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>int (samp_rate / baseband_freq)</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samples_per_symbol / 4</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>4</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>[0x8, 0xE, 0x0]</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>gen_packets</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import re \
    , exrex

import numpy as np
from gnuradio import gr

class blk (gr.sync_block):
    """
    Generates all possible combinations of 'n' bits packets that match the given pattern
    """

    def __init__ (self
                , n = 2
                , repetitions = 1
                , pattern = ".*"
                , spacing = 3
                , comb_spacing = 30
    ):  # only default arguments here
        """
        Constructor

        Args:
            n -&gt; Number of bits per packet

            repetitions -&gt; Number of times that every matched combination should be
                repeated

            pattern -&gt; Regex (accepted by 're') to filter the accepted bit strings

            spacing -&gt; Number of periods left blank between packets

            comb_spacing -&gt; Number of periods left blank between the last packet
                    of one combination and the first of the next combination.
        """
        gr.sync_block.__init__ (
            self,
            name = 'Packet source',
            in_sig = [],
            out_sig = [np.int8]
        )

        self.n = n
        self.repetitions = repetitions
        self.pattern = pattern
        self.spacing = spacing
        self.comb_spacing = comb_spacing

        self.remaining = []
        self.generator = self.gen_packet ()


    def gen_packet (self):
        """
        Infinite generator
        Generates all combinations of n_bits that matches the given pattern and repeats
        them again.

        Returns:
            A list with the generated combination
        """
        n = self.n
        spacing = self.spacing
        repetitions = self.repetitions
        pattern = self.pattern

        # Substitues '.' for '[01]', as packets are a binary string
        pattern = re.sub ("[.]", "[01]", pattern)
        # Python's regex substitutes '*' for {0, 4294967295}, and '+' for {1, 4294967295}.
        # To reduce the output of exrex, 4294967295 is changed for n
        pattern = re.sub ("[*]", "{0," + str (n) +  "}", pattern)
        pattern = re.sub ("[+]", "{1," + str (n) +  "}", pattern)


        if exrex.count (pattern, limit = n + 1) &lt; (2 ** self.n):

            # Generated with exrex (reversing the regular expression)

            while True:
                for b in exrex.generate (pattern, limit = n + 1):
                    if len (b) == n:
                        # Repeats the current combination 'repetitions' times, if it matches
                        for i in xrange (repetitions):
                            if (i == 0):
                                yield [2] * self.comb_spacing \
                                    + [ int (x) for x in b ] + [2] * spacing
                            else:
                                yield [ int (x) for x in b ] + [2] * spacing
                            print b

        else:
            # Normal generation (pure bruteforcing)

            regex = re.compile (pattern)
            b = 0
            while True:

                s = "{0:b}".format (b).zfill (n)

                if regex.match (s):
                    # Repeats the current combination 'repetitions' times, if it matches
                    for i in xrange (repetitions):
                        if (i == 0):
                            yield [2] * self.comb_spacing \
                                + [ int (x) for x in s ] + [2] * spacing
                        else:
                            yield [ int (x) for x in s ] + [2] * spacing
                        print s

                # Restarts the counter
                if b &gt;= ((2 ** n) - 1):
                    b = 0
                else:
                    b += 1


    def work (self, input_items, output_items):
        """
        Signal processing
        """
        extra_pkt = []
        # Fills the buffer with the current packet
        room = (len (output_items [0]) - len (self.remaining))

        # To avoid exceptions when output_items is little, takes only the previous items
        if room &lt;= 0:
            output_items [0][:] = np.array (self.remaining [:len (output_items [0])])
            self.remaining = self.remaining [len (output_items [0]):]

            return len (output_items [0])


        packet = []
        acc_len = 0

        while len (packet) &lt; room:
            tmp = self.generator.next ()
            acc_len += len (tmp)
            packet += tmp


        output_items [0][:] = np.array (
                                self.remaining
                                + packet [:room]
        )

        # Stores the remaining bits to be sent on the next buffer
        if acc_len &gt; room:
            self.remaining = packet [room:]
        else:
            self.remaining = []


        return len (output_items [0])
</value></param>
<param><key>comb_spacing</key><value>10</value></param>
<param><key>n</key><value>25</value></param>
<param><key>pattern</key><value>packet</value></param>
<param><key>repetitions</key><value>5</value></param>
<param><key>spacing</key><value>3</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>carrier_freq</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>carrier_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>fbw</key><value>4</value></param>
<param><key>interp</key><value>samples_per_symbol / 4</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gen_packets</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
