options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bruteforce
    output_language: python
  states: {}

blocks:
- name: baseband_freq
  id: variable
  parameters:
    value: '676'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 432.867e6
  states: {}
- name: packet
  id: variable
  parameters:
    value: '"010000010[01]0[01]0101000[01]0[01]0[01]0"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: int (samp_rate / baseband_freq)
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samples_per_symbol / 4)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0x8, 0xE, 0x0]'
  states: {}
- name: gen_packets
  id: epy_block
  parameters:
    _source_code: "\"\"\"\r\nEmbedded Python Blocks:\r\n\r\nEach this file is saved, GRC will instantiate the first class it finds to get\r\nports and parameters of your block. The arguments to __init__  will be the\r\nparameters. All of them are required to have default values!\r\n\"\"\"\r\nimport re \\\r\n    , exrex\r\n\r\nimport numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass blk (gr.sync_block):\r\n    \"\"\"\r\n    Generates all possible combinations of 'n' bits packets that match the given pattern\r\n    \"\"\"\r\n\r\n    def __init__ (self\r\n                , n = 2\r\n                , repetitions = 1\r\n                , pattern = \".*\"\r\n                , spacing = 3\r\n                , comb_spacing = 30\r\n    ):  # only default arguments here\r\n        \"\"\"\r\n        Constructor\r\n\r\n        Args:\r\n            n -> Number of bits per packet\r\n\r\n            repetitions -> Number of times that every matched combination should be\r\n                repeated\r\n\r\n            pattern -> Regex (accepted by 're') to filter the accepted bit strings\r\n\r\n            spacing -> Number of periods left blank between packets\r\n\r\n            comb_spacing -> Number of periods left blank between the last packet\r\n                    of one combination and the first of the next combination.\r\n        \"\"\"\r\n        gr.sync_block.__init__ (\r\n            self,\r\n            name = 'Packet source',\r\n            in_sig = [],\r\n            out_sig = [np.int8]\r\n        )\r\n\r\n        self.n = n\r\n        self.repetitions = repetitions\r\n        self.pattern = pattern\r\n        self.spacing = spacing\r\n        self.comb_spacing = comb_spacing\r\n\r\n        self.remaining = []\r\n        self.generator = self.gen_packet ()\r\n\r\n\r\n    def gen_packet (self):\r\n        \"\"\"\r\n        Infinite generator\r\n        Generates all combinations of n_bits that matches the given pattern and repeats\r\n        them again.\r\n\r\n        Returns:\r\n            A list with the generated combination\r\n        \"\"\"\r\n        n = self.n\r\n        spacing = self.spacing\r\n        repetitions = self.repetitions\r\n        pattern = self.pattern\r\n\r\n        # Substitues '.' for '[01]', as packets are a binary string\r\n        pattern = re.sub (\"[.]\", \"[01]\", pattern)\r\n        # Python's regex substitutes '*' for {0, 4294967295}, and '+' for {1, 4294967295}.\r\n        # To reduce the output of exrex, 4294967295 is changed for n\r\n        pattern = re.sub (\"[*]\", \"{0,\" + str (n) +  \"}\", pattern)\r\n        pattern = re.sub (\"[+]\", \"{1,\" + str (n) +  \"}\", pattern)\r\n\r\n\r\n        if exrex.count (pattern, limit = n + 1) < (2 ** self.n):\r\n\r\n            # Generated with exrex (reversing the regular expression)\r\n\r\n            while True:\r\n                for b in exrex.generate (pattern, limit = n + 1):\r\n\r\n                    # Spacing between packets\r\n                    yield [2] * self.comb_spacing\r\n\r\n                    if len (b) == n:\r\n                        # Repeats the current combination 'repetitions' times, if it matches\r\n                        for i in range (repetitions):\r\n\r\n                            yield [ int (x) for x in b ] + [2] * spacing\r\n                            print (b)\r\n\r\n        else:\r\n            # Normal generation (pure bruteforcing)\r\n\r\n            regex = re.compile (pattern)\r\n            b = 0\r\n            while True:\r\n\r\n                s = \"{0:b}\".format (b).zfill (n)\r\n\r\n                if regex.match (s):\r\n                    # Spacing between packets\r\n                    yield [2] * self.comb_spacing\r\n\r\n                    # Repeats the current combination 'repetitions' times, if it matches\r\n                    for i in range (repetitions):\r\n\r\n                        yield [ int (x) for x in s ] + [2] * spacing\r\n                        print (s)\r\n\r\n                # Restarts the counter\r\n                if b >= ((2 ** n) - 1):\r\n                    b = 0\r\n                else:\r\n                    b += 1\r\n\r\n\r\n    def work (self, input_items, output_items):\r\n        \"\"\"\r\n        Signal processing\r\n        \"\"\"\r\n        extra_pkt = []\r\n        # Fills the buffer with the current packet\r\n        room = (len (output_items [0]) - len (self.remaining))\r\n\r\n        # To avoid exceptions when output_items is little, takes only the previous items\r\n        if room <= 0:\r\n            output_items [0][:] = np.array (self.remaining [:len (output_items [0])])\r\n            self.remaining = self.remaining [len (output_items [0]):]\r\n\r\n            return len (output_items [0])\r\n\r\n\r\n        packet = []\r\n        acc_len = 0\r\n\r\n        while len (packet) < room:\r\n            tmp = next (self.generator)\r\n            acc_len += len (tmp)\r\n            packet += tmp\r\n\r\n\r\n        output_items [0][:] = np.array (\r\n                                self.remaining\r\n                                + packet [:room]\r\n        )\r\n\r\n        # Stores the remaining bits to be sent on the next buffer\r\n        if acc_len > room:\r\n            self.remaining = packet [room:]\r\n        else:\r\n            self.remaining = []\r\n\r\n\r\n        return len (output_items [0])"
    comb_spacing: '10'
    n: '25'
    pattern: packet
    repetitions: '5'
    spacing: '3'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: carrier_freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_freq
    fftsize: '1024'
    gui_hint: 0, 0, 1, 1
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1, 0, 1, 1
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '4'
    interp: int(samples_per_symbol / 4)
    taps: '1'
    type: fff
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [gen_packets, '0', digital_map_bb_0, '0']
- [rational_resampler_xxx_0, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
